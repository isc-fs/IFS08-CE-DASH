<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MT25QL128A_STM32H743_CUSTOM7.ewp</path>
  </project>
  <batchBuild/>
</workspace>

