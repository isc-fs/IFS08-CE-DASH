# IAR project MT25QL128A_STM32H743_CUSTOM7.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\Includes\CMSIS_Files; ..\..\Includes\Library_Files; ..\..\Includes\Loader_Files
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MT25QL128A_STM32H743_CUSTOM7.hex
  postbuild: cmd.exe /C copy "Debug\Exe\MT25QL128A_STM32H743_CUSTOM7.out" "..\..\..\MT25QL128A_STM32H743_CUSTOM7.stldr"
  ILINK.IlinkOutputFile: MT25QL128A_STM32H743_CUSTOM7.out
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkExtraOptions: --no_remove
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group Loader
    ../../Sources/Loader_Files/: Dev_Inf.c Loader_Src.c
  group STM32l4xx
    ../../Sources/Library_Files/: stm32l4xx_gpio.c stm32l4xx_quadspi.c stm32l4xx_rcc.c stm32l4xx_syscfg.c system_stm32l4xx.c
