# Keil uVision project MT25QL128A_STM32H743_CUSTOM7.uvproj, settings and files
target MT25QL128A_STM32H743_CUSTOM7 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MT25QL128A_STM32H743_CUSTOM7
  AfterMake: cmd.exe /C copy "!L" "..\..\..\@L.stldr"
  c flags: Optim=1
  c define: FLASH_MEM STM32L4xx STM32L4XX
  c include: ..\..\Includes\CMSIS_Files;..\..\Includes\Library_Files;..\..\Includes\Loader_Files
  scatter file: .\loader.sct
  link misc: --diag_suppress L6305
  group Loader
    ../../Sources/Loader_Files/: Dev_Inf.c Loader_Src.c
  group STM32FL4xx
    ../../Sources/Library_Files/: stm32l4xx_gpio.c stm32l4xx_quadspi.c stm32l4xx_rcc.c stm32l4xx_syscfg.c system_stm32l4xx.c
